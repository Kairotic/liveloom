# Repository Kairotic/liveloom

File README.md:

# Liveloom

A warp-weighted loom, live codeable via solenoids.

## lasercut.svg

This creates the shapes required to lasercut a loom from 3mm
material. I used baltic birch plywood, MDF would likely do just as
well.

## Other things needed

- 4mm diameter metal rod
- 25mm diameter wooden rod
- Solenoids - "DC 12V 10mm Push-Pull Actuator Frame Type Electromagnet
  Solenoid Electric Magnet" - can be found for about £2
  each. With this design, I recommend getting either 12 or 16.
- Relays - I used a board with 16 of them. "16-channel Relay Module
  Board 5v12v".
- Arduino (and 'jumper jerky' wire) to control the relays
- PSU for the relays
- PSU for the solenoids - This needs some power. I used "RS PRO 102W
  Embedded Switch Mode Power Supply SMPS, 8.5A, 12V dc". (You might
  need even more amps to power all your relays at once)
- Loom weights, one per thread - I recommend small plastic weighted
  kumihimo bobbins for this, then you can easily store the warp
  inside, but you can also use smallish bolts and wrap the warp around..
- Screws to attach the solenoids, I think I needed M2.5 screws for
  mine.
- wire to connect up the solenoids etc. This needs to be fairly heavy
  duty, to take the amps!
- diodes to protect everything against kickback from the
  solenoids. I still need to add these myself!

## Rough instructions

My plywood was bendier in one direction - basically if there is a
grain have it go horizontal otherwise E1/E2 will bend too much with
the weight of the solenoids.

A* and B* are the main legs and supports. D0 slots into the support
and is where I screw my relay switch board.

Below you see 'lollypop stick' heddles. Each has a 'mouth', two of the
things that look like capital As slot into each 'mouth', creating a
nice strike area for the solenoid. Half of the heddles have bends, so
the solenoids can be on two axes (doubling the number you can have in
a given amount of space).

The circles above the heddles are wooden washers to space the lollypop
sticks out so they line up with the solenoids, I woodglue one to each
heddle. These are then threaded onto a 4mm metal rod. I add a small
metal washer or two to line everything up with the solenoids.

E1 and E2 are what the solenoids are screwed on to.

C* are assembled with wood glue, and then slotted into the front of
the legs A4, with E1 and E2 and the 4mm rod slotted in using the
provided holes.

Contact alex@slab.org with any questions - I'd be happy offer advice
to get you up and running.

## WWL.hs

An experimental haskell library for live coding the loom.

Start ghci, and then initialise the library like this (replacing with the path to your arduino's USB connection):
```
:load WWL

(set, next, undo, again, show) <- startFs "/dev/serial/by-id/usb-Arduino__www.arduino.cc__0043_5573731323135141A191-if00"
```

Then code a structure like this:

```
set $ every 2 rev $ twill 1 $ cycle [up,down,down,up]
```

And run `next` to send the next line to the loom, `again` to send it again, or `undo` to go back.

## KiCad design solenoid/solenoid.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
J1, J2: Arduino; PinHeader_2x09_P2.54mm_Vertical
J3, J4: Conn_01x01_Male; Pin_D1.0mm_L10.0mm
J5, J6, J7, J8: Conn_01x01; MountingHole_2.2mm_M2_Pad_Via
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: TIP120; TO-220-3_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 2.2K; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal

Connections:
+12V: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), J2.16, J3.1
D1: J1.1, R1.2
D2: J1.3, R2.2
D3: J1.5, R3.2
D4: J1.7, R4.2
D5: J1.9, R5.2
D6: J1.11, R6.2
D7: J1.13, R7.2
D8: J1.15, R8.2
D9: J1.17, R9.2
D10: J1.18, R10.2
D11: J1.16, R11.2
D12: J1.14, R12.2
D13: J1.12, R13.2
D14: J1.10, R14.2
D15: J1.8, R15.2
D16: J1.6, R16.2
Earth: J1.2, J1.4, J2.18, J4.1, Q1.3 (E), Q2.3 (E), Q3.3 (E), Q4.3 (E), Q5.3 (E), Q6.3 (E), Q7.3 (E), Q8.3 (E), Q9.3 (E), Q10.3 (E), Q11.3 (E), Q12.3 (E), Q13.3 (E), Q14.3 (E), Q15.3 (E), Q16.3 (E)
unnamed: Q1.1 (B), R1.1
unnamed: Q2.1 (B), R2.1
unnamed: Q3.1 (B), R3.1
unnamed: Q4.1 (B), R4.1
unnamed: Q5.1 (B), R5.1
unnamed: Q6.1 (B), R6.1
unnamed: Q7.1 (B), R7.1
unnamed: Q8.1 (B), R8.1
unnamed: Q9.1 (B), R9.1
unnamed: Q10.1 (B), R10.1
unnamed: Q11.1 (B), R11.1
unnamed: Q12.1 (B), R12.1
unnamed: Q13.1 (B), R13.1
unnamed: Q14.1 (B), R14.1
unnamed: Q15.1 (B), R15.1
unnamed: Q16.1 (B), R16.1
S1: D1.2 (A), J2.17, Q1.2 (C)
S2: D2.2 (A), J2.15, Q2.2 (C)
S3: D3.2 (A), J2.13, Q3.2 (C)
S4: D4.2 (A), J2.11, Q4.2 (C)
S5: D5.2 (A), J2.9, Q5.2 (C)
S6: D6.2 (A), J2.7, Q6.2 (C)
S7: D7.2 (A), J2.5, Q7.2 (C)
S8: D8.2 (A), J2.3, Q8.2 (C)
S9: D9.2 (A), J2.1, Q9.2 (C)
S10: D10.2 (A), J2.2, Q10.2 (C)
S11: D11.2 (A), J2.4, Q11.2 (C)
S12: D12.2 (A), J2.6, Q12.2 (C)
S13: D13.2 (A), J2.8, Q13.2 (C)
S14: D14.2 (A), J2.10, Q14.2 (C)
S15: D15.2 (A), J2.12, Q15.2 (C)
S16: D16.2 (A), J2.14, Q16.2 (C)

Board: 2 copper layers, 132.0 x 79.0 mm, 56 parts (0 on the bottom side), 50 nets.

## Commit log

2019-07-22 initial version
2019-07-22 cc-by-sa 4.0 license
2019-07-22 Fix markdown
2019-07-22 haskell library and rough instructions
2019-09-12 cabal file for WWL
2019-09-15 looking viable
2019-09-20 first go
2019-09-25 getting draftworthy
2019-09-25 proofread
2019-09-26 getting there
2019-09-26 wahey
2019-11-15 de-anonymise
2019-12-12 final
2021-04-27 added solenoid kicad files and gerber/cnc gcode
2021-04-27 added svg plots
2021-07-22 mass production version updates
2021-08-12 initial
2021-08-19 works
2021-08-30 twiddles
2021-09-01 twiddle
2021-09-01 remove bounds on base
2021-09-01 hacks for easymode
2022-01-18 tweaks
2022-01-18 first go at patterning with python itertools
2022-01-18 add header
2022-01-19 Fix comment
2022-01-19 Try to implement twill (not working yet)
